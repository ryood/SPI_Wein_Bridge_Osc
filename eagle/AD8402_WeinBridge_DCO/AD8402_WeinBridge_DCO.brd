# Repository ryood/SPI_Wein_Bridge_Osc

## EAGLE design eagle/AD8402_WeinBridge_DCO/AD8402_WeinBridge_DCO.brd

Parts:
C1, C2: 0.47uF; C050-035X075
C3: 100uF; E2,5-7
C4, C8, C9: 0.1uF; C025-024X044
C5: 100uF; SANYO-OSCON_C6
C6, C7: 47uF; E2,5-6
D1, D2: 1N4148DO35-7; DO35-7
IC1: NJM2732; DIL08
IC2: AD8402_DIP14
IC3: TLE2426LP; TO226AA
JP1, JP5: SPI; 1X04
JP2, JP6: OUT; 1X02
JP3, JP7: PWR; 1X02
JP4: TP_GND; 1X02
LED1: GREEN; LED3MM
R1: 5k; B25P
R2: 2.2k; 0207/7
R3, R5: 100k; 0207/7
R4: 10k; 0207/7
R6: 1k; 0207/7

Connections:
+5V: C4.1, C5.+, C6.+, C8.1, IC1.8 (V+), IC2.6 (!SHDN), IC2.10 (!RS), IC2.11 (VDD), IC3.3 (I), JP3.1, JP7.1, LED1.A
CS: IC2.7 (!CS), JP1.3, JP5.3
GND: C4.2, C5.-, C7.-, C9.2, IC1.4 (V-), IC2.1 (AGND), IC2.5 (DGND), IC3.2, JP1.4, JP2.2, JP3.2, JP4.1, JP4.2, JP5.4, JP6.2, JP7.2, R5.1, R6.1
MOSI: IC2.8 (SDI), JP1.2, JP5.2
unnamed: IC1.2 (-IN), R2.2, R3.1, R4.1
unnamed: R1.E, R2.1
unnamed: LED1.K (C), R6.2
unnamed: C3.-, JP2.1, JP6.1, R5.2
unnamed: D1.C, D2.A, R3.2
unnamed: D1.A, D2.C, IC1.1 (OUT), IC1.5 (+IN), IC2.12 (W1), IC2.13 (A1), R4.2
unnamed: C1.1, C2.1, IC1.3 (+IN), IC2.3 (A2), IC2.4 (W2)
unnamed: C2.2, IC2.14 (B1)
unnamed: C3.+, IC1.6 (-IN), IC1.7 (OUT)
SCK: IC2.9 (CLK), JP1.1, JP5.1
VCC/2: C1.2, C6.-, C7.+, C8.2, C9.1, IC2.2 (B2), IC3.1 (O), R1.A, R1.S

Notes on the sheet:
※C1、C2は特性を揃える

Board: 2 copper layers, 70.8 x 45.7 mm, 28 parts (0 on the bottom side), 15 nets.

## Commit log

2017-09-01 Add fritzing files using AD8402
2017-09-01 Add a ealge project of AD8402_WeinBridge_DCO
2017-09-03 Before Routing Board Design
2017-09-13 Update eagle files
2017-09-13 Add some files
2017-09-13 Add a test chart.
2017-09-15 Update Test Chart
